# Repository hamadalfehaed/hamad-alfehaed

File README.md:

# hamad-alfehaed
The design is a DE0 GPIO to breadboard adapter, 40 pin adapter

## EAGLE design PCB Schematic.brd

Parts:
JP1: PINHD-2X20; 2X20
JP2, JP3: PINHD-1X20; 1X20

Connections:
3.3V: JP1.29, JP2.15
5.0V: JP1.11, JP2.6
GND: JP1.12, JP1.30, JP3.6, JP3.15
unnamed: JP1.1, JP2.1
unnamed: JP1.3, JP2.2
unnamed: JP1.5, JP2.3
unnamed: JP1.7, JP2.4
unnamed: JP1.9, JP2.5
unnamed: JP1.13, JP2.7
unnamed: JP1.15, JP2.8
unnamed: JP1.17, JP2.9
unnamed: JP1.19, JP2.10
unnamed: JP1.21, JP2.11
unnamed: JP1.23, JP2.12
unnamed: JP1.25, JP2.13
unnamed: JP1.27, JP2.14
unnamed: JP1.31, JP2.16
unnamed: JP1.33, JP2.17
unnamed: JP1.35, JP2.18
unnamed: JP1.37, JP2.19
unnamed: JP1.39, JP2.20
unnamed: JP1.40, JP3.20
unnamed: JP1.38, JP3.19
unnamed: JP1.36, JP3.18
unnamed: JP1.34, JP3.17
unnamed: JP1.32, JP3.16
unnamed: JP1.28, JP3.14
unnamed: JP1.26, JP3.13
unnamed: JP1.24, JP3.12
unnamed: JP1.22, JP3.11
unnamed: JP1.20, JP3.10
unnamed: JP1.18, JP3.9
unnamed: JP1.16, JP3.8
unnamed: JP1.14, JP3.7
unnamed: JP1.10, JP3.5
unnamed: JP1.8, JP3.4
unnamed: JP1.6, JP3.3
unnamed: JP1.4, JP3.2
unnamed: JP1.2, JP3.1

Board: 2 copper layers, 59.4 x 29.2 mm, 3 parts (0 on the bottom side), 39 nets.
